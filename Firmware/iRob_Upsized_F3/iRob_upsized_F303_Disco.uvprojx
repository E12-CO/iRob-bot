# Keil uVision project iRob_upsized_F303_Disco.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: STM32F303VCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: iRob_upsized_F303_Disco
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c include: .\src\src_app;.\src\src_drv;.\src\src_main
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group src_main
    ./src/src_main/: main.c
  group src_drv
    ./src/src_drv/: clk.c clk.h ros_usart.c ros_usart.h spi.c spi.h tim_qdec.c tim_qdec.h tim_pwm.c tim_pwm.h i2c.c i2c.h systick_millis.c systick_millis.h
  group src_app
    ./src/src_app/: app_ros_comm.c app_ros_comm.h app_sensor_lsm303dlhc.c app_sensor_lsm303dlhc.h app_sensor_l3gd20.c app_sensor_l3gd20.h app_sensor_adns5090.c app_sensor_adns5090.h app_io_manager.c app_io_manager.h app_motor_control.c app_motor_control.h app_robot_runner.c app_robot_runner.h app_gpio.h
software components: CMSIS:CORE 6.1.0, Device:Startup 1.11.3
