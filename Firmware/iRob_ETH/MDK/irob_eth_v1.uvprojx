# Keil uVision project irob_eth_v1.uvprojx, settings and files
target CH32F208RB (6220000::V6.22::ARMCLANG)
  device: CH32F208RB WCH
  pack: Keil.WCH32F2xx_DFP.1.0.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x28000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: irob_eth_v1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CH32F20x_D8W,SYSCLK_FREQ_120MHz_HSE=120000000UL
  c include: ..\App\Inc;..\Lib\Inc;..\Drv\Inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ../App/Src/: app_main.c app_tcpServer.c app_msgtype.c app_controlLoop.c
    ../App/Inc/: app_tcpServer.h app_msgtype.h app_controlLoop.h
  group Lib
    ../Lib/Src/: wchnet.lib
    ../Lib/Inc/: net_config.h
  group Drv
    ../Drv/Src/: gpio.c systick.c tim5.c tim2.c
    ../Lib/Src/: eth_driver_D8W.c
  group Startup
    ../Startup/: system_ch32f20x.c startup_ch32f20x_D8W.s
software components: CMSIS:CORE 6.2.0, CH32F2xx:StdPeriph Drivers:DBGMCU 1.0.0, CH32F2xx:StdPeriph Drivers:FLASH 1.0.0, CH32F2xx:StdPeriph Drivers:Framework 1.0.0, CH32F2xx:StdPeriph Drivers:GPIO 1.0.0, CH32F2xx:StdPeriph Drivers:RCC 1.0.0, CH32F2xx:StdPeriph Drivers:TIM 1.0.0
